Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: b3288021-a28f-41b3-aa7d-1d45158be395.ifc
Time: 2025-02-03T14:20:38
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcBuildingElementProxy, keramische tussenpan Nelskamp - Nibra Flachdachpan F-10 PRO natuurrood (601)
In: Bouwlaag
Material: terracotta
Pset_Data - WUID: AgAAAJ_bjwABAAAAmdYCAAVWkAAAhlIAAKtLAAAN1gIAe9ICAAAA; Hyperlink: https://bcb-online.nl/?WUID=AgAAAJ_bjwABAAAAmdYCAAVWkAAAhlIAAKtLAAAN1gIAe9ICAAAA; werkende lengte: 395 mm; serie: Nibra Flachdachpan F-10 PRO; vorstbestendig: True; gewicht per m²: 37,5 kg/m²; NL-SfB tabel 3: g9; werkende breedte: 254 mm; merk: Nelskamp; golfhoogte: 54 mm; breedte: 295 mm; gewicht per st: 3,75 kg/st; soortelijke warmte: 840 j/kg·k; STABU2: 33.41.10; lengte: 489 mm; toepassingsgebied: dak; hoogte: 54 mm; kleur: natuurrood (601); dikte: 13 mm; eenheid: st
